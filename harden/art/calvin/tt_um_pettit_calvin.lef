VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO tt_um_pettit_calvin
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  FOREIGN tt_um_pettit_calvin 0 0 ;
  SIZE 32.400 BY 47.400 ;
  SYMMETRY X Y ;
  OBS
      LAYER met4 ;
        RECT 0 0 32.400 47.400 ;
  END
END tt_um_pettit_calvin

END LIBRARY
